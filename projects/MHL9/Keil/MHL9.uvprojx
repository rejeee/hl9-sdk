# Keil uVision project MHL9.uvprojx, settings and files
target V3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MHL9 +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __CORTEX_M0 __CMSIS_RTOS NDEBUG
  c include: ..\..\..\kernel\CMSIS\Include;..\..\..\kernel\CMSIS\RTOS\RTX\SRC;..\..\..\kernel\CMSIS\RTOS\RTX\INC;..\..\..\bsp;..\..\..\bsp\cpu;..\..\..\bsp\cpu\HDSC;..\..\..\bsp\cpu\HDSC\HC32L13X;..\..\..\bsp\cpu\HDSC\HC32L13X\emdrv;..\..\..\bsp\cpu\HDSC\HC32L13X\driver\inc;..\..\..\bsp\platform;..\..\..\bsp\platform\common;..\..\..\libs;..\..\..\app;..\..\..\net;..\config;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: ..\..\..\libs\hl9.lib
  group APP
    ../../../app/: app.c main.c
  group BSP/cpu/HDSC/HC32L13X/driver/src
    ../../../bsp/cpu/HDSC/HC32L13X/driver/src/: aes.c ddl.c flash.c gpio.c interrupts_hc32l13x.c lpm.c lpt.c lpuart.c reset.c spi.c sysctrl.c uart.c wdt.c rtc.c
  group BSP/platform
    ../../../bsp/platform/: hl9.h platform.h
  group BSP
    ../../../bsp/: bsp.h bsp_RTX.h
  group HAL
    ../hal/: hal_led.c
  group CFG
    ../config/: RTX_Conf_CM.c app_cfg.h
  group Kernel/RTX
    ../../../kernel/CMSIS/RTOS/RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group Kernel/RTX/Keil
    ../../../kernel/CMSIS/RTOS/RTX/SRC/ARM/: HAL_CM0.c SVC_Table.s
  group Startup
    ../../../bsp/cpu/HDSC/HC32L13X/: system_hc32l13x.c
  group Startup/Keil
    ./: startup_hc32l13x.s
  group User
    ../: app_at.c app_mac.c app_project.c platform_mhl9.c platform_conf.h
