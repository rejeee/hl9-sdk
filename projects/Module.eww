<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MHL9\IAR\MHL9.ewp</path>
  </project>
  <batchBuild/>
</workspace>


